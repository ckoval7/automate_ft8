<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usb_tx_bpf</value></param>
<param><key>author</key><value>K3CPK</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>USB transmitter using complex band pass filter.</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>USB TX</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>audio_gain</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>600e-3</value></param>
<param><key>option</key><value>audio_gain</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>20</value></param>
<param><key>option</key><value>tx_bb_gain</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>carrier_level</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option</key><value>carrier_level</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_name</value></param>
<param><key>value</key><value>"ft8_qso.conf"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_width</value></param>
<param><key>value</key><value>2.7e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>high</value></param>
<param><key>value</key><value>low+filter_width</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>20</value></param>
<param><key>option</key><value>tx_if_gain</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>if_samp_rate</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>48e3</value></param>
<param><key>option</key><value>if_samp_rate</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>low</value></param>
<param><key>value</key><value>300</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>offset</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>5e3</value></param>
<param><key>option</key><value>offset</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>10</value></param>
<param><key>option</key><value>tx_rf_gain</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rf_samp_rate</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>2e6</value></param>
<param><key>option</key><value>rf_samp_rate</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_dev_string</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>hackrf=0</value></param>
<param><key>option</key><value>tx_device_string</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>144.174e6</value></param>
<param><key>option</key><value>tx_freq</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_sdr_ppm</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>tx_sdr_ppm</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>wav_file</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>./ft8_cq.wav</value></param>
<param><key>option</key><value>tx_wav_file</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>wav_samp_rate</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>12e3</value></param>
<param><key>option</key><value>wav_samp_rate</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>carrier_level</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>if_samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>offset</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>if_samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>interp_fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>high</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>low</value></param>
<param><key>samp_rate</key><value>if_samp_rate</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>audio_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>wav_file</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>corr0</key><value>tx_sdr_ppm</value></param>
<param><key>freq0</key><value>tx_freq-offset</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>tx_dev_string</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rf_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(wav_samp_rate)</value></param>
<param><key>interp</key><value>int(if_samp_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>int(if_samp_rate)</value></param>
<param><key>interp</key><value>int(rf_samp_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
