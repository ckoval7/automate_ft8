<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ssb_rx_rec</value></param>
<param><key>author</key><value>K3CPK</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Simple SSB receiver</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>SSB Receiver and Recorder</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>bb_gain</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_name</value></param>
<param><key>value</key><value>"./ft8_qso.conf"</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>freq</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>144.174e6</value></param>
<param><key>option</key><value>rx_freq</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>high</value></param>
<param><key>value</key><value>2.7e3</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>if_gain</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>if_samp_rate</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>48e3</value></param>
<param><key>option</key><value>if_sample_rate</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>low</value></param>
<param><key>value</key><value>300</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>offset</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>5e3</value></param>
<param><key>option</key><value>rx_offset</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>"./captures/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile</value></param>
<param><key>value</key><value>wav_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>25.4</value></param>
<param><key>option</key><value>rx_rf_gain</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rf_samp_rate</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>2.4e6</value></param>
<param><key>option</key><value>rf_sample_rate</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_ppm</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>rx_sdr_ppm</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>wav_samp_rate</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>12e3</value></param>
<param><key>option</key><value>wav_sample_rate</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>wav_save</value></param>
<param><key>config_file</key><value>file_name</value></param>
<param><key>value</key><value>ft8rx.wav</value></param>
<param><key>option</key><value>rx_wav_file</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, rf_samp_rate, 125000, 25000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>0.1</value></param>
<param><key>decay_rate</key><value>50e-6</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>1</value></param>
<param><key>reference</key><value>0.8</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter</value></param>
<param><key>decim</key><value>int(rf_samp_rate/if_samp_rate)</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>high</value></param>
<param><key>low_cutoff_freq</key><value>low</value></param>
<param><key>samp_rate</key><value>rf_samp_rate</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>recfile</value></param>
<param><key>samp_rate</key><value>12000</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>rf_samp_rate</value></param>
<param><key>taps</key><value>xlate_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>corr0</key><value>rx_ppm</value></param>
<param><key>freq0</key><value>freq-offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>rtl=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rf_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(if_samp_rate)</value></param>
<param><key>interp</key><value>int(wav_samp_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>band_pass_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
